SUMMARY = "CAN hat support image - production"

LICENSE = "MIT"

inherit core-image

CORE_IMAGE_EXTRA_INSTALL = "inotify-tools"

